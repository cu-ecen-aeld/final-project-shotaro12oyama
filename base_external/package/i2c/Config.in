## base_external/package/i2c/Config.in
```kconfig
config BR2_PACKAGE_I2C
	bool "i2c"
	help
	  Includes the scull and misc-modules.
```
